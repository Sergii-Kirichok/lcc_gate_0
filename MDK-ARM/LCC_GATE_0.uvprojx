# Keil uVision project LCC_GATE_0.uvprojx, settings and files
target LCC_GATE_0 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: LCC_GATE_0
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F107xC
  c misc: --C99
  c include: ../Inc; ../Middlewares/Third_Party/LwIP/src/include; ../Middlewares/Third_Party/LwIP/src/include/ipv4; ../Middlewares/Third_Party/LwIP/system; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Middlewares/Third_Party/LwIP/src/include/ipv4/lwip; ../Middlewares/Third_Party/LwIP/src/include/lwip; ../Middlewares/Third_Party/LwIP/src/include/netif; ../Middlewares/Third_Party/LwIP/src/include/posix; ../Middlewares/Third_Party/LwIP/src/include/posix/sys; ../Middlewares/Third_Party/LwIP/src/netif/ppp; ../Middlewares/Third_Party/LwIP/system/arch; ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: igmp.c ip_addr.c inet.c ip_frag.c icmp.c inet_chksum.c ip.c autoip.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: magic.c ipcp.c auth.c md5.c chpms.c fsm.c ppp.c chap.c ppp_oe.c vj.c randm.c lcp.c pap.c
    ../Middlewares/Third_Party/LwIP/src/core/snmp/: asn1_dec.c mib_structs.c mib2.c msg_in.c msg_out.c asn1_enc.c
    ../Middlewares/Third_Party/LwIP/src/netif/: slipif.c etharp.c
    ../Middlewares/Third_Party/LwIP/src/core/: dhcp.c sys.c pbuf.c tcp.c netif.c udp.c lwip_timers.c dns.c tcp_out.c memp.c stats.c mem.c tcp_in.c init.c raw.c def.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c netdb.c tcpip.c sockets.c err.c netifapi.c netbuf.c
  group Application/MDK-ARM
    ./: startup_stm32f107xc.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_eth.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash.c stm32f1xx_hal_dma.c stm32f1xx_hal_rcc.c
  group Application/User
    ../Src/: stm32f1xx_hal_msp.c lwip.c main.c stm32f1xx_it.c ethernetif.c tcp_server.c
software components: CMSIS:CORE 4.1.0
